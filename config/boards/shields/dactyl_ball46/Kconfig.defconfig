## config/boards/shields/dactyl_ball46/Kconfig.defconfig
```kconfig
if SHIELD_DACTYL_BALL46

config ZMK_KEYBOARD_NAME
    default "Dactyl Ball46"

endif
```
